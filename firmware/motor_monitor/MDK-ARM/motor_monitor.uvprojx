# Keil uVision project motor_monitor.uvprojx, settings and files
target motor_monitor (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: motor_monitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/Inc;../BSP/Inc;../Services/Inc;../Drivers/DHT11/Inc;../Drivers/LightSensor/Inc;../Drivers/Motor/Inc;../Drivers/HCSR04/Inc;..\Drivers\ACS712\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ../App/Src/: app.c
  group BSP
    ../BSP/Src/: bsp_led.c
  group Services
    ../Services/Src/: logger.c ring_buffer.c cli.c sensor_manager.c fault_manager.c motor_manager.c distance_manager.c
  group DHT11
    ../Drivers/DHT11/Src/: dht11.c
  group LightSensor
    ../Drivers/LightSensor/Src/: light_sensor.c
  group Motor
    ../Drivers/Motor/Src/: motor_driver.c
  group HCSR04
    ../Drivers/HCSR04/Src/: hcsr04.c
  group ACS712
    ../Drivers/ACS712/Src/: acs712.c
software components: CMSIS:CORE 6.2.0
